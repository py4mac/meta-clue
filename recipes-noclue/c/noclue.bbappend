inherit externalsrc
EXTERNALSRC = "${TOPDIR}/../meta-noclue/repices-noclue/c/noclue"
